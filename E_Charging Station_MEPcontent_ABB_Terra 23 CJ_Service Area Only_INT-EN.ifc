Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-03-19T15:53:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 19 15:53:44 2018 * Host: B3ROBRAWR2791 * Database: C:\Users\CS\AppData\Local\Temp\{A525CACF-C42F-4AC0-A41B-14C08E55FBC5}\ifc * Database version: 5507 * Database creation date: Mon Mar 19 15:53:43 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 19 15:53:44 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 19 15:53:44 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcOutlet: T23 CJ, E_Charging Station_MEPcontent_ABB_Terra 23 CJ_Service Space_INT-EN:T23 CJ:1314856
In: V00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 218-227-224, Color RGB 127-127-127, Color RGB 255-000-000, Color RGB 055-055-055, Color RGB 200-200-200, Color RGB 236-236-231, Color RGB 087-093-094
Type - Dimensions - Depth: 780 mm; Height: 1900 mm; Width: 565 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical - Loads - Input AC Power Connection: 3P + N + PE; Input Frequency: 50 Hz or 60Hz; Input Voltage: 400 VAC +/-10 %; Maximum Rated Input Current: 32 A; Maximum Rated Input Power: 23000 W
Type - Identity Data - Article Description: Multi-standard DC (20kW) fast charger. Terra 23 CJ is compatible with all CHAdeMO and CCS vehicles currently on the road; Article Type: T23 CJ; Category: EL_POWERCONSUMER; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Multi-standard DC (20kW) fast charger. Terra 23 CJ is compatible with all CHAdeMO and CCS vehicles currently on the road; EMCS Version: 3.0; ETIM Article Class: EC002883; Family Version: 11.10; Manufacturer: ABB; Manufacturer Art. No.: Terra 23 CJ; Manufacturer URL: http://new.abb.com/ev-charging/full-global-portfolio; MEPcontent Class: CHARGING_STATION; Model: T23 CJ; Product Line: ABB EV chargers; Revit Version: 2016; Type Name: T23 CJ; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Cable: Color RGB 055-055-055; Charger: Color RGB 127-127-127; Glass: Color RGB 218-227-224; Grey: Color RGB 087-093-094; Light Grey: Color RGB 127-127-127; Red: Color RGB 255-000-000; White: Color RGB 236-236-231; White Charger Part: Color RGB 200-200-200
Type - Other - Category: Electrical Equipment; Family Name: E_Charging Station_MEPcontent_ABB_Terra 23 CJ_Service Space_INT-EN; Foundation Height: 600 mm; Foundation Length: 500 mm; Foundation Width: 814 mm; Service Space Back Clearance: 100 mm; Service Space Front Clearance: 600 mm; Service Space Left Clearance: 510 mm; Service Space Right Clearance: 510 mm; Service Space Top Clearance: 100 mm
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 14.2878 m2; Volume: 5.49876 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 400 V/3-23000 VA
Identity Data - Function Code: E6113; Mark: 2
Other - Family: E_Charging Station_MEPcontent_ABB_Terra 23 CJ_Service Space_INT-EN: T23 CJ; Family and Type: E_Charging Station_MEPcontent_ABB_Terra 23 CJ_Service Space_INT-EN: T23 CJ; Foundation Offset: 0 mm; Service Space Top Clearance Condition: 100 mm; Type: E_Charging Station_MEPcontent_ABB_Terra 23 CJ_Service Space_INT-EN: T23 CJ; Type Id: E_Charging Station_MEPcontent_ABB_Terra 23 CJ_Service Space_INT-EN: T23 CJ
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Foundation Soil: no; Service Space: yes
